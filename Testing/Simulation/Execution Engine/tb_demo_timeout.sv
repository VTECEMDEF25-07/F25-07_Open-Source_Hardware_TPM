`timescale 1ns/1ps
module tb_demo_timeout;
reg  clock_i;
reg  reset_n_i;
reg  start_i;
reg  operational_i;
reg [15:0] command_tag_i;
reg [31:0] command_size_i;
wire [11:0] command_addr_o;
reg [7:0] command_byte_i;
wire  response_valid_o;
wire [31:0] response_code_o;
wire [11:0] response_length_o;
reg [11:0] response_addr_i;
wire [7:0] response_byte_o;
reg  response_consumed_i;
reg  supervisor_recovered_i;
reg  supervisor_last_committed_i;
reg [31:0] supervisor_last_id_i;
reg [31:0] supervisor_last_handle_i;
reg [3:0] supervisor_last_reason_i;
wire  busy_o;
wire  scrub_done_o;
wire  recovery_required_o;
reg  aes_client_active_i;
wire  store_use_allowed_o;
wire  gen_job_valid_o;
reg  gen_job_ready_i;
wire [1:0] gen_job_profile_o;
wire [1:0] gen_job_mode_o;
wire [31:0] gen_job_id_o;
reg  gen_done_valid_i;
wire  gen_done_ready_o;
reg [31:0] gen_done_id_i;
reg [31:0] gen_done_handle_i;
reg [1:0] gen_done_profile_i;
reg [1:0] gen_done_mode_i;
reg [3:0] gen_done_core_status_i;
reg [3:0] gen_done_setup_error_i;
reg [3:0] gen_done_teardown_error_i;
reg  gen_done_ownership_committed_i;
reg  gen_busy_i;
reg  gen_available_i;
reg  gen_recovery_required_i;
reg  gen_scrub_done_i;
wire  release_valid_o;
reg  release_ready_i;
wire [31:0] release_handle_o;
reg  release_rsp_valid_i;
wire  release_rsp_ready_o;
reg [31:0] release_rsp_code_i;
wire  modexp_job_valid_o;
reg  modexp_job_ready_i;
wire [31:0] modexp_job_id_o;
wire [11:0] modexp_base_addr_o;
wire [11:0] modexp_exponent_addr_o;
wire [11:0] modexp_modulus_addr_o;
wire [11:0] modexp_result_addr_o;
wire [15:0] modexp_operand_bytes_o;
reg  modexp_status_valid_i;
wire  modexp_status_ready_o;
reg [31:0] modexp_status_id_i;
reg [31:0] modexp_status_cycles_i;
reg [3:0] modexp_status_code_i;
reg [15:0] modexp_status_result_bytes_i;
reg  modexp_recovery_required_i;
reg  modexp_ram_req_valid_i;
wire  modexp_ram_req_ready_o;
reg  modexp_ram_req_write_i;
reg [11:0] modexp_ram_req_addr_i;
reg [7:0] modexp_ram_req_wdata_i;
wire  modexp_ram_rsp_valid_o;
reg  modexp_ram_rsp_ready_i;
wire [7:0] modexp_ram_rsp_rdata_o;
wire  modexp_ram_rsp_error_o;
wire  ram_req_valid_o;
reg  ram_req_ready_i;
wire  ram_req_write_o;
wire [11:0] ram_req_addr_o;
wire [7:0] ram_req_wdata_o;
reg  ram_rsp_valid_i;
wire  ram_rsp_ready_o;
reg [7:0] ram_rsp_rdata_i;
reg  ram_rsp_error_i;
wire  ram_clear_valid_o;
reg  ram_clear_ready_i;
reg  ram_clear_done_valid_i;
wire  ram_clear_done_ready_o;
reg  ram_scrub_done_i;

reg [7:0] packet[0:25]; integer cycles; reg passed=0;
initial clock_i=0; always #5 clock_i=~clock_i;
execution_engine_demo_packet #(.WIDTH(32)) dut(.*);
defparam dut.coordinator.GENERATION_DEADLINE=64'd10;
always @(posedge clock_i) command_byte_i<=packet[command_addr_o];
task tick; begin @(posedge clock_i); #1; end endtask
initial begin
reset_n_i=0;
start_i=0;
operational_i=0;
command_tag_i=0;
command_size_i=0;
command_byte_i=0;
response_addr_i=0;
response_consumed_i=0;
supervisor_recovered_i=0;
supervisor_last_committed_i=0;
supervisor_last_id_i=0;
supervisor_last_handle_i=0;
supervisor_last_reason_i=0;
aes_client_active_i=0;
gen_job_ready_i=0;
gen_done_valid_i=0;
gen_done_id_i=0;
gen_done_handle_i=0;
gen_done_profile_i=0;
gen_done_mode_i=0;
gen_done_core_status_i=0;
gen_done_setup_error_i=0;
gen_done_teardown_error_i=0;
gen_done_ownership_committed_i=0;
gen_busy_i=0;
gen_available_i=0;
gen_recovery_required_i=0;
gen_scrub_done_i=0;
release_ready_i=0;
release_rsp_valid_i=0;
release_rsp_code_i=0;
modexp_job_ready_i=0;
modexp_status_valid_i=0;
modexp_status_id_i=0;
modexp_status_cycles_i=0;
modexp_status_code_i=0;
modexp_status_result_bytes_i=0;
modexp_recovery_required_i=0;
modexp_ram_req_valid_i=0;
modexp_ram_req_write_i=0;
modexp_ram_req_addr_i=0;
modexp_ram_req_wdata_i=0;
modexp_ram_rsp_ready_i=0;
ram_req_ready_i=0;
ram_rsp_valid_i=0;
ram_rsp_rdata_i=0;
ram_rsp_error_i=0;
ram_clear_ready_i=0;
ram_clear_done_valid_i=0;
ram_scrub_done_i=0;

 operational_i=1; command_tag_i=16'h8001; command_size_i=26;
 gen_available_i=1; gen_scrub_done_i=1; ram_scrub_done_i=1;
 for(integer j=0;j<26;j=j+1) packet[j]=0;
 packet[10]=1; packet[11]=1; packet[17]=42;
 repeat(4) tick; @(negedge clock_i); reset_n_i=1; repeat(10) tick;
 @(negedge clock_i); start_i=1; tick; @(negedge clock_i); start_i=0;
 cycles=0; while(!recovery_required_o) begin tick; cycles++; if(cycles>100) $fatal(1,"deadline missing"); end
 if(response_valid_o || !busy_o || store_use_allowed_o || gen_job_valid_o) $fatal(1,"timeout fabricated completion");
 repeat(10) tick; if(response_valid_o || !recovery_required_o) $fatal(1,"recovery not held");
 @(negedge clock_i); reset_n_i=0; tick;
 if(response_valid_o || gen_job_valid_o) $fatal(1,"reset transfer");
 @(negedge clock_i); reset_n_i=1; repeat(10) tick;
 if(recovery_required_o || busy_o || !scrub_done_o) $fatal(1,"reset recovery");
 passed=1; $display("DEMO_TIMEOUT_PASS no fabricated completion, admission blocked, shared reset recovery"); $finish;
end
initial begin #100000; $fatal(1,"watchdog"); end
endmodule
